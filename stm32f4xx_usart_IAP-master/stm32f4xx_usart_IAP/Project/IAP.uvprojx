# Keil uVision project IAP.uvprojx, settings and files
target IAP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: IAP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\app;..\bsp\IAP;..\stdperiph_Drive\inc;..\stdperiph_Drive\src;..\system\delay;..\system\sys;..\system\usart;..\core;..\bsp\LED;..\bsp\flash
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group bsp
    ../bsp/IAP/: iap.c
    ../bsp/LED/: led.c
    ../bsp/flash/: flash.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group stdperiph_Drive
    ../stdperiph_Drive/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c
  group core
    ../core/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
